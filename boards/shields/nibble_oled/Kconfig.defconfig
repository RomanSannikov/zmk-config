## boards/shields/nibble_oled/Kconfig.defconfig
```kconfig
if SHIELD_NIBBLE_OLED

choice ZMK_DISPLAY_STATUS_SCREEN
    default ZMK_DISPLAY_STATUS_SCREEN_CUSTOM
endchoice

endif
```
